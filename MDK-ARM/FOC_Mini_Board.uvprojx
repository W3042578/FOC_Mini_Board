# Keil uVision project FOC_Mini_Board.uvprojx, settings and files
target FOC_Mini_Board (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FOC_Mini_Board +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MDK-ARM;./Application/Detail;./Algorithm;./Application/Encoder;./Application/Function;./Hardware;.\Infrastructure
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/CMSIS
    ./Infrastructure/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/Encoder
    ./Application/Encoder/: encoder.c
  group Application/Function
    ./Application/Function/: basic_function.c modbus.c object_commicate.c filter.c
  group MDK-ARM/Algorithm
    ./Algorithm/: control_loop.c foc.c table.c
  group MDK-ARM/Infrastructure
    ./Infrastructure/: adc.c dma.c gpio.c hal_my.c i2c.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group MDK-ARM/Hardware
    ./Hardware/: parameter.c
software components: CMSIS:CORE 5.6.0
